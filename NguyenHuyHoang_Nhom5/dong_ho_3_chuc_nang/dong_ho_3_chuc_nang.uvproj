# Keil uVision project dong_ho_3_chuc_nang.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dong_ho_3_chuc_nang +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: main.c
    ../Lib/: Delay.c LCD4.c Rtc_Ds1307.c Soft_I2C.c
